options:
  parameters:
    author: SDR-Zero
    comment: 信息波 f3 渐进抗干扰结构图；运行入口 tx_radio2.py；默认展示 balanced 档
    description: Pluto RX -> optional DC blocker -> steep FIR -> GFSK demod -> UDP
    generate_options: qt_gui
    id: tx_radio2_flow
    output_language: python
    title: info RX anti-jam f3
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: 等效采样率；首版不做 2.083M 重采样
    value: '1000000'
  states: {}
- name: target_freq
  id: variable
  parameters:
    comment: 红 433.2M；蓝由 f3 RPC 切到 433.92M
    value: '433200000'
  states: {}
- name: target_sens
  id: variable
  parameters:
    comment: 规则 V2 信息波 Sensitivity
    value: '1.5628'
  states: {}
- name: rf_bandwidth
  id: variable
  parameters:
    comment: balanced 默认 600k；baseline 1M；strong 540k
    value: '600000'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    comment: balanced 35；削顶继续降，弱信号消失则升
    value: '35'
  states: {}
- name: fir_cutoff
  id: variable
  parameters:
    comment: balanced 260k
    value: '260000'
  states: {}
- name: fir_transition
  id: variable
  parameters:
    comment: balanced 20k
    value: '20000'
  states: {}
- name: blocks_udp_sink_0
  id: blocks_udp_sink
  parameters:
    comment: 解调 bit -> info_decoder_f3
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '14346'
    psize: '1472'
    type: byte
    vlen: '1'
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    comment: balanced/strong 使用 32；baseline 由 tx_radio2.py 运行时旁路
    length: '32'
    long_form: 'True'
    type: complex
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    comment: 首版保留稳定 gfsk_demod；下一阶段再试显式 symbol_sync
    freq_error: '0.0048'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '47'
    sensitivity: target_sens
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    auto_filter: 'True'
    bandwidth: rf_bandwidth
    bbdc: 'True'
    buffer_size: '32768'
    comment: SDR-B；模拟带宽必须使用 rf_bandwidth，不能写死 1M
    frequency: target_freq
    gain1: '''manual'''
    manual_gain1: rx_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    uri: '''ip:192.168.3.1'''
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: 高抑制度信息波专用 FIR
    cutoff_freq: fir_cutoff
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: fir_transition
    win: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    color1: '"gray"'
    color2: '"blue"'
    comment: 输入0=原始 IQ；输入1=滤波后 IQ
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    label1: '"raw before FIR"'
    label2: '"filtered"'
    name: '"info anti-jam: raw / filtered"'
    nconnections: '2'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    comment: 与 f3 RPC_URL 一致
    port: '8081'
  states: {}

connections:
- [dc_blocker_xx_0, '0', low_pass_filter_0, '0']
- [digital_gfsk_demod_0, '0', blocks_udp_sink_0, '0']
- [iio_pluto_source_0, '0', dc_blocker_xx_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', digital_gfsk_demod_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '1']

metadata:
  file_format: 1
