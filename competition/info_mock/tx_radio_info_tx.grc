options:
  parameters:
    author: SDR-Zero
    comment: Info TX mock | Pluto=SDR-A 192.168.2.1 | UDP:12345 XMLRPC:8082
    description: UDP -> GFSK Mod SPS=47 -> Pluto Sink
    generate_options: qt_gui
    id: tx_radio
    output_language: python
    title: info_mock TX (V2)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: target_freq
  id: variable
  parameters:
    comment: RED 433.2M / BLUE 433.92M
    value: '433200000'
  states: {}
- name: target_sens
  id: variable
  parameters:
    comment: V2 broadcast Sensitivity
    value: '1.5628'
  states: {}
- name: tx_atten
  id: variable
  parameters:
    comment: 交叉测默认10；越大越弱。勿用40近场（会Header=0）
    value: '10'
  states: {}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '12345'
    psize: '1472'
    type: byte
    vlen: '1'
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: '47'
    sensitivity: target_sens
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: tx_atten
    auto_filter: 'True'
    bandwidth: '1000000'
    buffer_size: '32768'
    comment: CHANGE URI to TX Pluto
    cyclic: 'False'
    frequency: target_freq
    samplerate: '1000000'
    uri: '''ip:192.168.2.1'''
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: info_tx
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '8082'
  states: {}

connections:
- [blocks_udp_source_0, '0', digital_gfsk_mod_0, '0']
- [digital_gfsk_mod_0, '0', iio_pluto_sink_0, '0']
- [digital_gfsk_mod_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
