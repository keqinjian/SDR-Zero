options:
  parameters:
    author: keqinjian
    comment: 干扰波 RX | Pluto URI 在 iio_pluto_source_0 = ip:192.168.2.1 (SDR-A) | UDP 14348 | XMLRPC 8080
    generate_options: qt_gui
    id: tx_radio
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: target_freq
  id: variable
  parameters:
    value: '432200000'
  states: {}
- name: target_sens
  id: variable
  parameters:
    comment: V2 jam L1 Sensitivity
    value: '2.8194'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.001'
    threshold: '-100'
  states: {state: disabled}
- name: blocks_udp_sink_0
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '14348'
    psize: '1472'
    type: byte
    vlen: '1'
  states: {}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '12347'
    psize: '1472'
    type: byte
    vlen: '1'
  states: {state: disabled}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0048'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '47'
    sensitivity: target_sens
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: '47'
    sensitivity: target_sens
  states: {state: disabled}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10'
    auto_filter: 'True'
    bandwidth: '250000'
    buffer_size: '32768'
    comment: 【已禁用】旧 TX Sink，勿启用；URI 仅占位
    cyclic: 'False'
    frequency: target_freq
    samplerate: '1000000'
    uri: '''ip:192.168.2.1'''
  states: {state: disabled}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    auto_filter: 'True'
    bandwidth: '1000000'
    bbdc: 'True'
    buffer_size: '32768'
    comment: ★★★ 改 RX Pluto IP 看这里 uri ★★★ 干扰波 SDR-A = 192.168.2.1（与 tx_radio.py 的 pluto_uri 一致）
    frequency: target_freq
    gain1: '''manual'''
    manual_gain1: '40'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: '1000000'
    uri: '''ip:192.168.2.1'''
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '8080'
  states: {}

connections:
- [digital_gfsk_demod_0, '0', blocks_udp_sink_0, '0']
- [iio_pluto_source_0, '0', digital_gfsk_demod_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
