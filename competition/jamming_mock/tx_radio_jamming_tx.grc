options:
  parameters:
    author: SDR-Zero
    comment: Jamming TX mock | Pluto=SDR-B 192.168.3.1 | UDP:12347 XMLRPC:8083
    description: UDP -> GFSK Mod SPS=47 -> Pluto Sink
    generate_options: qt_gui
    id: tx_radio
    output_language: python
    title: jamming_mock TX (V2)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: target_freq
  id: variable
  parameters:
    comment: RED L1 432.2 / L2 432.5 / L3 432.8
    value: '432200000'
  states: {}
- name: target_sens
  id: variable
  parameters:
    comment: L1 2.8194 / L2 2.5681 / L3 0.6517
    value: '2.8194'
  states: {}
- name: tx_atten
  id: variable
  parameters:
    comment: jam is strong; start small atten
    value: '10'
  states: {}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '12347'
    psize: '1472'
    type: byte
    vlen: '1'
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: '47'
    sensitivity: target_sens
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: tx_atten
    auto_filter: 'True'
    bandwidth: '1000000'
    buffer_size: '32768'
    comment: CHANGE URI to TX Pluto
    cyclic: 'False'
    frequency: target_freq
    samplerate: '1000000'
    uri: '''ip:192.168.3.1'''
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    color1: '"red"'
    fc: '0'
    fftsize: '1024'
    name: jamming_tx
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '8083'
  states: {}

connections:
- [blocks_udp_source_0, '0', digital_gfsk_mod_0, '0']
- [digital_gfsk_mod_0, '0', iio_pluto_sink_0, '0']
- [digital_gfsk_mod_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
